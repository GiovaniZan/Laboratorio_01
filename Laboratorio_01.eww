<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Exercicios\Exercicio1\Exercicio1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Exercicios\Exercicio2\Exercicio2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Exercicios\Exercicio3\Exercicio3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Exercicios\Exercicio4\Exercicio4.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Exercicios\Exercicio5\Exercicio5.ewp</path>
    </project>
    <batchBuild />
</workspace>
